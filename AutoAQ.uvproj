# Keil uVision project AutoAQ.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: AutoAQ +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\qpn\include;..\C51_lib
  group 80C51
    ./: STARTUP.A51 main.c bsp.c blinky.c
  group C51_lib
    ../C51_lib/: usart.c Timer.c LED.c
  group qpn
    ../qpn/src/qvn/: qvn.c
    ../qpn/src/qfn/: qepn.c qfn.c
