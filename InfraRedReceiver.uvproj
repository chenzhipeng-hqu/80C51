# Keil uVision project InfraRedReceiver.uvproj, settings and files
target InfraRedReceiver (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: InfraRedReceiver +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C51_lib;Task
  group main
    ./: STARTUP.A51 main.c
  group lib
    ../C51_lib/: EasyKey.c LCD1602.c LED.c Timer.c PCA.c InfraRed.c InfraRed_NEC.c task.c
  group task
    ./Task/: LCD1602Task.c LEDTask.c InfraRedTask.c
