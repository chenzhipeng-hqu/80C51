# Keil uVision project qpnano.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: qpnano +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\qpn\include;..\C51_lib;.\Task
  group 80C51
    ./: STARTUP.A51 main.c
  group C51_lib
    ../C51_lib/: LED.c Timer.c usart.c EasyKey.c
  group Task
    ./Task/: KEYTask.c LEDTask.c UsartTask.c
